File: Hypnos V3.4/HypnosV3.4.sch (EAGLE design)
At the start: 36 parts, among them Q1 DMN65D8L-7, Q2 DMN65D8L-7

Commit message: Add files via upload
Other:
- moved on the sheet: C1, D1
